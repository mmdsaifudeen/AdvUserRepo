SRC_URI += "file://zc706.cfg"

FILESEXTRAPATHS_prepend := "${THISDIR}/linux-xlnx:"

